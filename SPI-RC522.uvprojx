# Keil uVision project SPI-RC522.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI-RC522
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOSTING
  c include: ..\SPI-RC522
  asm define: DEBUG_ENABLE_SEMIHOSTING
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c spi.c rc522.c rc522.h delay.c delay.h uart.c uart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
